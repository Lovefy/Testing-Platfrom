# Keil uVision project Bootloader_prj.uvprojx, settings and files
target Bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader_prj +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\src\User;..\src\Application\ManagementCenter\AppConfig;..\src\Application\Update;..\src\Driver-Layer;..\src\Kernel-1.1\Libraries\STM32F1xx_StdPeriph_Driver\inc;..\src\Middle-Layer;..\src\Kernel-1.1\System;..\src\Application\ManagementCenter\LedModule
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/User/: main.c
  group Application
    ../src/Application/ManagementCenter/AppConfig/: AppConfig.c
  group Middle_layer
    ../src/Middle-Layer/: CRC_Check.c
  group Driver_layer
    ../src/Driver-Layer/: BspCfg.c IRBsp.c ledBsp.c OutInBsp.c StmflashBsp.c UsartBsp.c WdgBsp.c IoBsp.c
  group Kernel
    ../src/Kernel-1.1/System/: core_cm3.c Malloc.c stm32f10x_it.c sys.c system_stm32f10x.c usart.c
    ../src/Kernel-1.1/Libraries/STM32F1xx_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    ../src/Kernel-1.1/StartUp/: startup_stm32f10x_cl.s
  group Update
    ../src/Application/Update/: timerledbsp.c UpdateManModule.c
